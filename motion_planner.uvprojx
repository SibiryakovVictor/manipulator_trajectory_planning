# Keil uVision project motion_planner.uvprojx, settings and files
target NoTests (6140000::V6.14::ARMCLANG)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: motion_planner +hex
  c flags: Optim=5 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: UMBA_DONT_USE_RETARGET, USE_FULL_ASSERT, USE_STDPERIPH_DRIVER,  __FPU_PRESENT, __STDC_LIMIT_MACROS, USE_HSE, STM32F407xx, STM32F40_41xxx, HSE_VALUE=8000000, EIGEN_NO_DEBUG,EIGEN_DONT_ALIGN,EIGEN_NO_MALLOC
  c include: .\src;.\src\mcu_support_package\inc;.\src\spl\inc;.\src\spl;.\src\cmsis
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress 6329 --diag_suppress 6314
  group common_functions
    ./src/Common_Functions/: common_functions.cpp common_functions.h
  group main
    ./src/Main/: main.cpp
    ./src/: project_config.h
    ./src/main/config_space/graph/: graph_parameters.h i_edges_list.h i_nodes_list.h graph.cpp graph.h graph_typedefs.h
    ./src/main/config_space/: conf_space_dims.h
    ./src/main/config_space/point/: point.cpp point.h
    ./src/main/tools/float_operations/: float_operations.cpp float_operations.h
    ./src/main/path/: path_typedefs.h path_parameters.h
    ./src/main/tools/intervals/: intervals.cpp intervals.h
    ./src/main/config_space/segment/: segment.cpp segment.h
    ./src/main/env/manipulator/: manipulator_controller.cpp manipulator_controller.h manip_parameters.h
    ./src/main/env/obstacles/: obst_parameters.h obstacles.cpp obstacles.h
    ./src/main/env/collision_detection/: collision_detector.cpp collision_detector.h collision_check_pairs.h collision_table.cpp collision_table.h
    ./src/main/env/motion_common/: motion_common.cpp motion_common.h
    ./src/main/env/primitives/obb/: obb.cpp obb.h
    ./src/main/env/primitives/attached_detail/: attached_detail.cpp attached_detail.h
    ./src/main/path/trajectory_iterator/: trajectory_iterator.cpp trajectory_iterator.h
    ./src/main/path/path_generator/: path_generator.cpp path_generator.h
    ./src/main/path/path_searcher/: path_searcher.cpp path_searcher.h
    ./src/main/est/: est.cpp est.h
    ./src/main/config_space/uniform_config_gen/: uniform_config_gen.cpp uniform_config_gen.h
    ./src/main/motion_planner/: motion_planner.cpp motion_planner.h
    ./src/main/tools/configurator/: configurator.cpp configurator.h
    ./src/main/env/info_loader/: info_loader.cpp info_loader.h init_typedefs.h
    E:/project_template_f4/src/main/motion_planner/: task_planning.h
    ./src/main/env/: env_def.h
    ./src/main/config_space/free_cspace_validator/: free_cspace_validator.cpp free_cspace_validator.h
    ./src/main/config_space/graph/shortest_path_searcher/: i_shortest_path_searcher.h
    ./src/main/config_space/graph/shortest_path_searcher/a_star/: a_star.cpp a_star.h priority_queue.cpp
  group mcu_support_package
    ./src/mcu_support_package/: system_stm32f4xx.c
    ./src/mcu_support_package/arm/: startup_stm32f401xc.s startup_stm32f401xe.s startup_stm32f405xx.s startup_stm32f407xx.s startup_stm32f410cx.s startup_stm32f410rx.s startup_stm32f410tx.s startup_stm32f411xe.s startup_stm32f412cx.s startup_stm32f412rx.s startup_stm32f412vx.s startup_stm32f412zx.s startup_stm32f413xx.s startup_stm32f415xx.s startup_stm32f417xx.s startup_stm32f423xx.s startup_stm32f427xx.s startup_stm32f429xx.s startup_stm32f437xx.s startup_stm32f439xx.s startup_stm32f446xx.s startup_stm32f469xx.s startup_stm32f479xx.s
  group retarget
    ./src/retarget/: retarget.cpp
  group spl
    ./src/spl/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
